FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"


PACKAGECONFIG:append = " kms "
